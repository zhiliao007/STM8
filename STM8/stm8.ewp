# IAR project stm8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8S105
  ICCSTM8.CCIncludePath2: user; STM8S_StdPeriph_Driver\inc; user\bsp\led; user\bsp\uart; user\bsp\key; user\bsp\esp8266
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
  group src
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
  group user
    user/: delay.c delay.h main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group user/bsp
    user/bsp/esp8266/: bsp_esp8266.c bsp_esp8266.h
    user/bsp/key/: bsp_key.c bsp_key.h
    user/bsp/led/: bsp_led.c bsp_led.h
    user/bsp/uart/: bsp_uart.c bsp_uart.h
